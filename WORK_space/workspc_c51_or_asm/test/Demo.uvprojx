# Keil uVision project Demo.uvprojx, settings and files
target Target 1 (5050106::V5.05 update 1 (build 106)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Demo +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: .\CMSIS;.\Users\Inc;.\Users\src;.\User\Inc;.\StdPeriphDriver\inc;.\User\Src;.\User\Inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/Src/: main.c public.c stm32f10x_it.c iic.c lcd1602.c
    ../Goodbye/USER/: stack.c
  group StdPeriphDriver
    ./StdPeriphDriver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c
  group CMSIS
    ./CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ./StartUp/: startup_stm32f10x_md.s
