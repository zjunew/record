    ORG 0000H
    LJMP START
    ORG 0003H
    LJMP IN00
    ORG 0013H
    LJMP IN11
    ORG 0030H
START:
	MOV P0 , #00H
	MOV R0 , #01H
    SETB EA

    SETB EX0
    SETB EX1
    SETB IT0
    SETB IT1
MAIN:
    
    SJMP $

IN00:
	LCALL DELAY
    MOV A, R0
    RL A
    MOV R0, A
	MOV P0 ,R0
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
    RETI
    

IN11:
    MOV R1, #08H
LOOP:
    ACALL DELAY
    MOV A, R0
    RL A
    MOV R0, A 
	MOV P0, R0
    DJNZ R1, LOOP
	LCALL DELAY
	LCALL DELAY
	LCALL DELAY
    JB P3.3, TURN_OFF
    RETI

TURN_OFF:
    MOV P0, #00H
	MOV R0, #01H
    RETI 

DELAY:
    MOV R2, #0FFH
DELAY1:
    MOV R3, #0FFH
DELAY2:
    DJNZ R3, DELAY2
    DJNZ R2, DELAY1
    RET
END